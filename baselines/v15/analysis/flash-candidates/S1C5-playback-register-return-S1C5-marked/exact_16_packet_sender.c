/* Guarded exact 16-packet sender for S1-C5 Marked Playback Note.
 * Default build has live USB disabled and only supports dry-run validation.
 */
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#ifdef S1C5_ENABLE_LIVE_USB
#include <time.h>
#include <libusb.h>
#endif
#include "../../../../../src/sha256.h"
#define S1C5_PACKET_COUNT 16u
#define S1C5_PACKET_SIZE 163u
#define S1C5_USB_MIDI_BYTES 220u
#define S1C5_USB_MIDI_PACKET_SIZE 4u
#define S1C5_MAX_PATH 4096u
static const uint8_t EXPECTED_HEADER[6] = {0xf0,0x43,0x00,0x00,0x01,0x1b};
static const char CONFIRM_TOKEN[] = "SEND-SMK37PRO-V15-S1C5-ALL-C4-7C7A8AC8-523CCBC8-14D65142-EFAB2E0D";
struct packet_spec { unsigned order; unsigned slot; unsigned trigger_note; unsigned playback_note; const char *file; uint8_t sha256[SMK37_SHA256_LENGTH]; };
static const struct packet_spec PACKETS[S1C5_PACKET_COUNT] = {
    { 1u, 0u, 36u, 60u, "slot00-trigger36-playback60-all-c4-direct-product-163.bin", { 0x7c, 0x7a, 0x8a, 0xc8, 0xd5, 0x7b, 0xd7, 0x8b, 0x8d, 0x53, 0x1f, 0xa8, 0x99, 0x7e, 0x7d, 0x9c, 0x18, 0xce, 0x4e, 0x0d, 0x8a, 0x26, 0x7c, 0xc2, 0x25, 0x49, 0xba, 0x71, 0xd5, 0xe3, 0xe9, 0xc4 } },
    { 2u, 1u, 37u, 60u, "slot01-trigger37-playback60-all-c4-direct-product-163.bin", { 0x52, 0x3c, 0xcb, 0xc8, 0x1e, 0xef, 0x76, 0x6f, 0xc7, 0x3b, 0xda, 0x72, 0xa7, 0x8d, 0x3a, 0x28, 0xba, 0x3f, 0x1f, 0xca, 0xbc, 0x11, 0x46, 0xdb, 0x78, 0x25, 0x26, 0x73, 0xf8, 0xd5, 0xed, 0x7a } },
    { 3u, 2u, 38u, 60u, "slot02-trigger38-playback60-all-c4-direct-product-163.bin", { 0x14, 0xd6, 0x51, 0x42, 0xc5, 0x2f, 0xbd, 0x47, 0x75, 0xab, 0x07, 0x16, 0x39, 0x88, 0x6c, 0x20, 0x3c, 0xc0, 0x3d, 0x86, 0x0d, 0xeb, 0x62, 0xe6, 0xde, 0x25, 0xc0, 0x48, 0xcb, 0x9a, 0x71, 0x2b } },
    { 4u, 3u, 39u, 60u, "slot03-trigger39-playback60-all-c4-direct-product-163.bin", { 0xef, 0xab, 0x2e, 0x0d, 0xb1, 0xe4, 0x44, 0xd4, 0xab, 0x8e, 0x96, 0xcd, 0x71, 0x25, 0x82, 0x5f, 0xdb, 0xd0, 0x44, 0x5e, 0x3e, 0x05, 0xb8, 0x43, 0x6a, 0xe7, 0xbb, 0xd2, 0xae, 0x83, 0x03, 0x64 } },
    { 5u, 4u, 40u, 60u, "slot04-trigger40-playback60-all-c4-direct-product-163.bin", { 0x98, 0x1e, 0x07, 0x72, 0xac, 0x58, 0x17, 0x4c, 0xb9, 0x4a, 0x17, 0x94, 0xbb, 0xda, 0xc1, 0x0d, 0xa9, 0xc2, 0x67, 0x9a, 0x0f, 0x69, 0x11, 0x2b, 0x14, 0xa1, 0x14, 0xd7, 0x5d, 0x70, 0x48, 0x1b } },
    { 6u, 5u, 41u, 60u, "slot05-trigger41-playback60-all-c4-direct-product-163.bin", { 0xd7, 0x3e, 0x23, 0x64, 0x82, 0xec, 0xd7, 0xd9, 0xb7, 0x91, 0xea, 0x61, 0x19, 0xb1, 0x3d, 0x63, 0xb0, 0x9e, 0xae, 0x55, 0x65, 0xf6, 0x82, 0xb8, 0xf2, 0xdc, 0x0b, 0x46, 0x78, 0x27, 0x75, 0x79 } },
    { 7u, 6u, 42u, 60u, "slot06-trigger42-playback60-all-c4-direct-product-163.bin", { 0x85, 0x62, 0x5d, 0x99, 0x9b, 0x3c, 0x23, 0xb5, 0x78, 0x36, 0x2f, 0xde, 0x17, 0xe9, 0x02, 0x2d, 0xb1, 0x6e, 0xf9, 0xec, 0xde, 0x59, 0x26, 0xe1, 0x98, 0xf3, 0x20, 0x69, 0x77, 0xcd, 0xba, 0x17 } },
    { 8u, 7u, 43u, 60u, "slot07-trigger43-playback60-all-c4-direct-product-163.bin", { 0x3e, 0x06, 0x35, 0x19, 0x76, 0xcd, 0xd9, 0x0b, 0x3e, 0x88, 0x8b, 0x32, 0xcc, 0xca, 0x87, 0x16, 0xde, 0x99, 0x1c, 0x95, 0xff, 0x44, 0xeb, 0x73, 0xe9, 0xc2, 0x6a, 0x3b, 0x91, 0x21, 0x50, 0xdd } },
    { 9u, 8u, 44u, 60u, "slot08-trigger44-playback60-all-c4-direct-product-163.bin", { 0xef, 0x96, 0x62, 0x8a, 0x3f, 0x2c, 0xb2, 0xa2, 0xb6, 0x02, 0x86, 0x87, 0xe1, 0xdc, 0x9f, 0xa8, 0x9f, 0x14, 0x7e, 0xdf, 0x7b, 0x4c, 0x4e, 0xb2, 0x29, 0xb7, 0xd2, 0x72, 0x50, 0x70, 0x48, 0x05 } },
    { 10u, 9u, 45u, 60u, "slot09-trigger45-playback60-all-c4-direct-product-163.bin", { 0xc6, 0x48, 0x3d, 0xab, 0xc9, 0xe1, 0xa8, 0x63, 0xf2, 0x68, 0x2b, 0x5c, 0x11, 0xea, 0x8a, 0x91, 0xe3, 0xef, 0x38, 0x21, 0x29, 0x26, 0x93, 0x0d, 0x8d, 0xe2, 0x4a, 0xfa, 0x3d, 0xb6, 0xf9, 0xde } },
    { 11u, 10u, 46u, 60u, "slot10-trigger46-playback60-all-c4-direct-product-163.bin", { 0x11, 0xc7, 0xdf, 0xae, 0x80, 0xeb, 0x8d, 0xda, 0xf8, 0x8e, 0xc9, 0x71, 0xff, 0x1b, 0x3c, 0xe8, 0xb4, 0xd7, 0x68, 0x94, 0xf4, 0x55, 0x0e, 0xc3, 0xa0, 0xb5, 0x11, 0x3c, 0x7e, 0x58, 0xbd, 0xde } },
    { 12u, 11u, 47u, 60u, "slot11-trigger47-playback60-all-c4-direct-product-163.bin", { 0xa9, 0x7d, 0x43, 0xe1, 0x35, 0x11, 0x77, 0xf4, 0xb7, 0xe4, 0x77, 0x0b, 0x21, 0x70, 0xd0, 0x7a, 0xe7, 0xd7, 0xdb, 0xd3, 0x3b, 0xd6, 0xbb, 0x64, 0x39, 0xa4, 0x41, 0xcb, 0x66, 0xf7, 0x4a, 0x68 } },
    { 13u, 12u, 48u, 60u, "slot12-trigger48-playback60-all-c4-direct-product-163.bin", { 0x36, 0x80, 0xc3, 0xab, 0xf1, 0x4c, 0x6a, 0x13, 0x09, 0x6f, 0xe5, 0x69, 0x53, 0x78, 0x9b, 0xc2, 0x57, 0x2f, 0xe2, 0xfd, 0x0d, 0x82, 0x24, 0x8f, 0x8e, 0x4e, 0x89, 0x34, 0x82, 0xa3, 0xbe, 0x19 } },
    { 14u, 13u, 49u, 60u, "slot13-trigger49-playback60-all-c4-direct-product-163.bin", { 0x66, 0x11, 0xe7, 0x5b, 0xfb, 0x8b, 0x11, 0x20, 0x6f, 0x63, 0x03, 0xa6, 0x3f, 0xdf, 0x6d, 0x50, 0xee, 0x9b, 0xeb, 0x8a, 0x72, 0xbe, 0x2e, 0x69, 0xf9, 0x23, 0x3a, 0x8f, 0x87, 0xe9, 0x3f, 0x3a } },
    { 15u, 14u, 50u, 60u, "slot14-trigger50-playback60-all-c4-direct-product-163.bin", { 0x8b, 0x3b, 0xbb, 0xcc, 0xf1, 0x03, 0xbd, 0x41, 0xea, 0x93, 0x43, 0x0b, 0x69, 0x4b, 0xe1, 0xb8, 0xab, 0x17, 0xd9, 0xa2, 0x9e, 0xd0, 0xbe, 0xe3, 0xd6, 0xfc, 0x05, 0x70, 0xe7, 0xd9, 0x57, 0x21 } },
    { 16u, 15u, 51u, 60u, "slot15-trigger51-playback60-all-c4-direct-product-163.bin", { 0xb0, 0x6e, 0x83, 0xfd, 0xf0, 0x97, 0x2a, 0x65, 0x2c, 0xa4, 0x56, 0x1e, 0xb0, 0x8c, 0x63, 0x12, 0xb5, 0x1b, 0xe2, 0x4c, 0x54, 0xc2, 0x61, 0x9a, 0x1d, 0x6c, 0x2d, 0x67, 0xcc, 0x2b, 0xf3, 0x0c } }
};
static int build_path(char *out, size_t out_size, const char *dir, const char *file) { int n = snprintf(out, out_size, "%s/%s", dir, file); return (n < 0 || (size_t)n >= out_size) ? 1 : 0; }
static int read_file_exact(const char *path, uint8_t packet[S1C5_PACKET_SIZE]) { FILE *f = fopen(path, "rb"); int extra; if (!f) { perror(path); return 1; } if (fread(packet, 1, S1C5_PACKET_SIZE, f) != S1C5_PACKET_SIZE) { fprintf(stderr, "S1-C5 packet must be exactly %u bytes: %s\n", (unsigned)S1C5_PACKET_SIZE, path); fclose(f); return 1; } extra = fgetc(f); fclose(f); if (extra != EOF) { fprintf(stderr, "S1-C5 packet has trailing bytes: %s\n", path); return 1; } return 0; }
static size_t packetize(const uint8_t *sysex, size_t length, uint8_t *events, size_t capacity) { size_t input = 0, output = 0; while (input < length) { size_t remaining = length - input; size_t count = remaining > 3 ? 3 : remaining; uint8_t cin; if (output + S1C5_USB_MIDI_PACKET_SIZE > capacity) return 0; cin = remaining > 3 ? 0x04 : (remaining == 1 ? 0x05 : (remaining == 2 ? 0x06 : 0x07)); events[output] = cin; events[output + 1] = sysex[input]; events[output + 2] = count > 1 ? sysex[input + 1] : 0; events[output + 3] = count > 2 ? sysex[input + 2] : 0; input += count; output += S1C5_USB_MIDI_PACKET_SIZE; } return output; }
static int verify_packet(const char *dir, const struct packet_spec *spec, uint8_t packet[S1C5_PACKET_SIZE], uint8_t events[S1C5_USB_MIDI_BYTES]) { uint8_t digest[SMK37_SHA256_LENGTH]; char path[S1C5_MAX_PATH]; size_t event_len; if (build_path(path, sizeof(path), dir, spec->file) != 0 || read_file_exact(path, packet) != 0) return 1; if (memcmp(packet, EXPECTED_HEADER, sizeof(EXPECTED_HEADER)) != 0 || packet[S1C5_PACKET_SIZE - 1] != 0xf7 || packet[161] != (uint8_t)spec->playback_note) { fprintf(stderr, "S1-C5 order %u slot %u trigger %u playback %u framing/playback mismatch\n", spec->order, spec->slot, spec->trigger_note, spec->playback_note); return 1; } smk37_sha256(packet, S1C5_PACKET_SIZE, digest); if (memcmp(digest, spec->sha256, sizeof(digest)) != 0) { fprintf(stderr, "S1-C5 order %u packet SHA-256 mismatch\n", spec->order); return 1; } event_len = packetize(packet, S1C5_PACKET_SIZE, events, S1C5_USB_MIDI_BYTES); if (event_len != S1C5_USB_MIDI_BYTES || events[event_len - 4] != 0x05 || events[event_len - 3] != 0xf7) { fputs("USB-MIDI packetization invariant failed\n", stderr); return 1; } return 0; }
#ifdef S1C5_ENABLE_LIVE_USB
static int send_verified(uint8_t events[S1C5_PACKET_COUNT][S1C5_USB_MIDI_BYTES]) { (void)events; fputs("live USB path intentionally not implemented in this artifact; use only after separate authorization and implementation review\n", stderr); return 2; }
#else
static int send_verified(uint8_t events[S1C5_PACKET_COUNT][S1C5_USB_MIDI_BYTES]) { (void)events; fputs("send BLOCK: live USB sender is disabled in the offline validation build\n", stderr); return 2; }
#endif
static void usage(const char *p) { fprintf(stderr, "usage:\n  %s dry-run <packet-dir>\n  %s send <packet-dir> --confirm %s\n", p, p, CONFIRM_TOKEN); }
int main(int argc, char **argv) { uint8_t packets[S1C5_PACKET_COUNT][S1C5_PACKET_SIZE]; uint8_t events[S1C5_PACKET_COUNT][S1C5_USB_MIDI_BYTES]; if (argc != 3 && argc != 5) { usage(argv[0]); return 2; } for (unsigned i = 0; i < S1C5_PACKET_COUNT; ++i) if (verify_packet(argv[2], &PACKETS[i], packets[i], events[i]) != 0) return 2; if (strcmp(argv[1], "dry-run") == 0 && argc == 3) { puts("S1-C5 Marked 16-packet sender dry-run PASS: triggers 36..51 all map to Playback Note C4 (60), 16 exact packets, no USB/MIDI opened"); return 0; } if (strcmp(argv[1], "send") == 0 && argc == 5 && strcmp(argv[3], "--confirm") == 0 && strcmp(argv[4], CONFIRM_TOKEN) == 0) return send_verified(events); usage(argv[0]); return 2; }
